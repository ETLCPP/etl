<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>ETL</name>
    <file>
      <name>$PROJ_DIR$\..\..\algorithm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\alignment.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\array.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\bitset.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\container.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\crc16.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\crc16.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\crc16_ccitt.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\crc16_ccitt.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\crc16_kermit.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\crc16_kermit.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\crc32.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\crc32.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\crc64_ecma.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\crc64_ecma.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\crc8_ccitt.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\crc8_ccitt.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cyclic_value.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\deque.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\deque_base.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\doxygen.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\endian.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\enum_type.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\error_handler.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\error_handler.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\exception.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\factorial.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\fibonacci.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\forward_list.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\forward_list_base.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\function.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\functional.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\ideque.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\iforward_list.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\ilist.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\integral_limits.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\ipool.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\iqueue.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\istack.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\ivector.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\largest.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\list.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\list_base.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\log.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\nullptr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\numeric.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\observer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\parameter_type.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\pool.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\power.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\queue.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\queue_base.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\smallest.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\stack.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\stack_base.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\static_assert.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\type_traits.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\variant.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\vector.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\vector_base.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\visitor.h</name>
    </file>
  </group>
  <group>
    <name>Test</name>
    <file>
      <name>$PROJ_DIR$\..\test_compile.cpp</name>
      <configuration>
        <name>Debug</name>
      </configuration>
    </file>
  </group>
</project>


