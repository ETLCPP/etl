# IAR project etl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: COMPILER_IAR; PLATFORM_ARM
  ICCARM.CCIncludePath2: U:\Users\John\Documents\Programming\GitHub\etl
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group ETL
    ../../: algorithm.h alignment.h array.h bitset.h container.h crc16.cpp crc16.h crc16_ccitt.cpp crc16_ccitt.h crc16_kermit.cpp crc16_kermit.h crc32.cpp crc32.h crc64_ecma.cpp crc64_ecma.h crc8_ccitt.cpp crc8_ccitt.h cyclic_value.h deque.h deque_base.h doxygen.h endian.h enum_type.h error_handler.cpp error_handler.h exception.h factorial.h fibonacci.h forward_list.h forward_list_base.h function.h functional.h ideque.h iforward_list.h ilist.h imap.h integral_limits.h io_port.h ipool.h iqueue.h istack.h ivector.h largest.h list.h list_base.h log.h map.h map_base.h nullptr.h numeric.h observer.h parameter_type.h pool.h power.h queue.h queue_base.h smallest.h stack.h stack_base.h static_assert.h type_traits.h variant.h vector.h vector_base.h visitor.h
  group Test
    ../: test_compile.cpp
