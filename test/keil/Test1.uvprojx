# Keil uVision project Test1.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: Test1
  c flags: Optim=1 wLevel=2
  c define: PLATFORM_ARM,COMPILER_KEIL, ETL_THROW_EXCEPTIONS
  c misc: --exceptions
  c include: ..\..\..\etl;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Test
    ../: test_compile.cpp
  group Support
    ./: core_cm7.h startup_ARMCM7.s system_ARMCM7.c core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group ETL
    ../../: algorithm.h alignment.h array.h bitset.h container.h crc8_ccitt.h crc16.h crc16_ccitt.h crc16_kermit.h crc32.h crc64_ecma.h cyclic_value.h deque.h doxygen.h endian.h enum_type.h exception.h factorial.h fibonacci.h forward_list.h function.h functional.h ideque.h iforward_list.h ilist.h imap.h integral_limits.h ipool.h iqueue.h istack.h ivector.h largest.h list.h map.h log.h nullptr.h numeric.h observer.h parameter_type.h pool.h power.h queue.h smallest.h stack.h static_assert.h type_traits.h variant.h vector.h visitor.h crc8_ccitt.cpp crc16.cpp crc16_ccitt.cpp crc16_kermit.cpp crc32.cpp crc64_ecma.cpp ibitset.h ihash.h io_port.h error_handler.h
  group Private
    ../../private/: deque_base.h flat_map_base.h flat_multimap_base.h flat_multiset_base.h flat_set_base.h forward_list_base.h list_base.h map_base.h multimap_base.h multiset_base.h pool_base.h priority_queue_base.h queue_base.h set_base.h stack_base.h unordered_map_base.h vector_base.h
