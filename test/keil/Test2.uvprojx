# Keil uVision project Test2.uvprojx, settings and files
target Target 1 (6070000::V6.7::.\ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Test2
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __STDC_LIMIT_MACROS
  c include: ..\..\src;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.1.0\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Test
    ../: test_embedded_compile.cpp
    ./: system_stm32f4xx.c startup_stm32f401xe.s
  group ETL
    ../../src/: algorithm.h alignment.h array.h basic_string.h binary.h bitset.h bloom_filter.h callback.h char_traits.h checksum.h container.h crc8_ccitt.cpp crc8_ccitt.h crc16.cpp crc16.h crc16_ccitt.cpp crc16_ccitt.h crc16_kermit.cpp crc16_kermit.h crc32.cpp crc32.h crc64_ecma.cpp crc64_ecma.h cstring.h cyclic_value.h debounce.h debug_count.h deque.h doxygen.h enum_type.h error_handler.cpp error_handler.h etl_arduino.h exception.h factorial.h fibonacci.h file_error_numbers.txt fixed_iterator.h flat_map.h flat_multimap.h flat_multiset.h flat_set.h fnv_1.h forward_list.h frame_check_sequence.h fsm.h fsm_generator.h function.h functional.h generate.bat generate_fsm.bat generate_message_router.bat hash.h icache.h ihash.h instance_count.h integral_limits.h intrusive_forward_list.h intrusive_links.h intrusive_list.h intrusive_queue.h intrusive_stack.h io_port.h iterator.h jenkins.h largest.h largest_generator.h list.h log.h map.h memory.h message.h message_bus.h message_router.h message_router_generator.h message_types.h multimap.h multiset.h murmur3.h nullptr.h numeric.h observer.h optional.h packet.h parameter_type.h pearson.cpp pearson.h platform.h pool.h power.h priority_queue.h queue.h radix.h random.cpp random.h ratio.h reference_flat_map.h reference_flat_multimap.h reference_flat_multiset.h reference_flat_set.h scheduler.h set.h smallest.h smallest_generator.h stack.h static_assert.h task.h type_def.h type_traits.h type_traits_generator.h u16string.h u32string.h unordered_map.h unordered_multimap.h unordered_multiset.h unordered_set.h user_type.h utility.h variant.h vector.h visitor.h wstring.h endianness.h constant.h
