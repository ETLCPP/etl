# Keil uVision project ArmTimerCallbacks.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ArmTimerCallbacks
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\src;../../src/c;..\ArmTimerCallbacks - C
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: main.c ecl_user.h
    ../../src/c/: ecl_timer.c ecl_timer_list.c ecl_timer.h ecl_timer_list.h
software components: CMSIS:CORE 5.0.2, Board Support:Buttons 1.1.0, Board Support:LED 1.1.0, Device:Startup 2.6.0
